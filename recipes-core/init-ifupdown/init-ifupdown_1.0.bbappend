FILESEXTRAPATHS_prepend_sama5d4-lorix-one := "${THISDIR}/${BPN}-${PV}:"
