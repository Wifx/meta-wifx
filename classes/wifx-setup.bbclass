# Override ubi image generation
IMAGE_CLASSES += " wifx-wimg"
