DESCRIPTION = "Image with LORIX One support."

LICENSE = "MIT"
PR = "r1"

require wifx-base-image.inc

