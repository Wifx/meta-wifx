DESCRIPTION = "Image with LORIX One support."

LICENSE = "MIT"
PR = "r0"

require wifx-base.inc

