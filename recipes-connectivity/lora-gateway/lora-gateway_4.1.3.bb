require lora-gateway.inc

LICENSE = "SEMTECH"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a2bdef95625509f821ba00460e3ae0eb"

PR = "r2"

KTAG = "v4.1.3"
