PACKAGECONFIG =+ "perl"
RDEPENDS_${PN}-misc =+ "perl"
