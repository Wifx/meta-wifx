PR = "r0"

require clouds-manager.inc

