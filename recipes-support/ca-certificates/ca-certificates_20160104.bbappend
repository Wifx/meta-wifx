FILESEXTRAPATHS_append := ":${THISDIR}/${BPN}"
SRC_URI_append = " file://0001-update-ca-certificates-reactivate-c-rehash.patch"
